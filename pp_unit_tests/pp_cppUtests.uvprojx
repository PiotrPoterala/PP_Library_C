# Keil uVision project pp_cppUtests.uvprojx, settings and files
target Target 1 (6130001::V6.13.1::.\ARMCLANG)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: pp_cppUtests
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F429xx,  UNIT_TESTS
  c include: ..\PP_List_Library;..\..\cppUtest\include;..\PP_Pins
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ../PP_List_Library/: pp_const_ports_masks_list.c
  group unit_test_lib
    ./: cpputest.lib
  group tests
    ./: AllTests.cpp pconstPortsMasks_test.cpp
  group mocks
    ../PP_Pins/: def_pins_mock.h
software components: CMSIS:CORE 5.3.0, Compiler:I/O:STDOUT 1.2.0, Device:Startup 2.6.2
